# Keil uVision project monitor.uvprojx, settings and files
target monitor (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: monitor +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: -DNDEBUG
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;./App;./Int/EEPROM;./Int/OLED;./Int/M24C02;./Int/Encoder;./freemodbus/modbus/include;./freemodbus/modbus/rtu;./freemodbus/port;./Int/Can
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group App
    ./App/: App_Display.c App_Display.h App_Key.c App_Key.h App_ModbusID.c App_ModbusID.h App_Motor_Value.c App_Motor_Value.h App_Motor_PID.c App_Motor_PID.h App_Modbus.c App_Modbus.h App_Can.c App_Can.h
  group Int/OLED
    ./Int/OLED/: Int_font.h Int_OLED.c Int_OLED.h
  group Int/M24C02
    ./Int/M24C02/: Int_M24C02.c Int_M24C02.h
  group Int/Encoder
    ./Int/Encoder/: Int_Encoder.c Int_Encoder.h
  group freemodbus
    ./freemodbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ./freemodbus/modbus/ascii/: mbascii.c
    ./freemodbus/modbus/rtu/: mbcrc.c mbrtu.c
    ./freemodbus/modbus/tcp/: mbtcp.c
    ./freemodbus/port/: port.c portevent.c portserial.c porttimer.c
    ./freemodbus/modbus/: mb.c
  group Int/Can
    ./Int/Can/: Int_Can.c Int_Can.h
software components: CMSIS:CORE 4.3.0
