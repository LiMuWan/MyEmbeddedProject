# Keil uVision project net_session.uvprojx, settings and files
target net_session (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: net_session +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Source/App;../FreeRTOS/include;../FreeRTOS/portable;../Source/Driver/W5500;../Source/Int/W5500;../Source/Driver/W5500/W5500;../Source/Int/MQTT;../Source/Driver/MQTT;../Source/Driver/MQTT/MQTTPacket;../Source/Driver/MQTT/MQTTPacket/src;../Source/Int/Modbus;../Source/Com;../Source/Int/Can
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/portable
    ../FreeRTOS/portable/: heap_4.c port.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Source/App
    ../Source/App/: App_Main.c App_Main.h App_ConsoleToGateWay.c App_ConsoleToGateWay.h App_GateWayToConsole.c App_GateWayToConsole.h
  group Source/Driver/W5500
    ../Source/Driver/W5500/W5500/: w5500.c
    ../Source/Driver/W5500/: socket.c wizchip_conf.c
  group Source/Driver/MQTT
    ../Source/Driver/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
    ../Source/Driver/MQTT/MQTTPacket/src/: MQTTConnect.h MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTPublish.h MQTTSerializePublish.c MQTTSubscribe.h MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribe.h MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c StackTrace.h
  group Source/Int/W5500
    ../Source/Int/W5500/: Int_W5500.c
  group Source/Int/MQTT
    ../Source/Int/MQTT/: Int_MQTT.c Int_MQTT.h
  group Source/Int/Modbus
    ../Source/Int/Modbus/: Int_Modbus.c Int_Modbus.h
  group Source/Com
    ../Source/Com/: mbcrc.c mbcrc.h cJSON.c cJSON.h
  group Source/Int/Can
    ../Source/Int/Can/: Int_Can.c Int_Can.h
software components: CMSIS:CORE 4.3.0
